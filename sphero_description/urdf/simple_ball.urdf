Commit message: Pushing all changes at once

File: sphero_description/urdf/simple_ball.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.056; visual sphere radius=0.056
